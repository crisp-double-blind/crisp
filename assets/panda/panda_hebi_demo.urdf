Commit message: tidy code

File: assets/panda/panda_hebi_demo.urdf (robot description, URDF)
Before this commit: robot panda_hebi, 10 links, 9 joints
Links:
- link nut: geometry collision mesh filename=../boltnut/nut_demo.obj; visual mesh filename=../boltnut/nut_demo.obj
